## west.yml
```yaml
manifest:
  projects:
    - name: zmk
      url: https://github.com/innovaker/zmk
      revision: modular-v1
      import: true
```
